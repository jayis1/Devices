#include "protocol.h"
#include <string.h>

/* CRC-16/CCITT-FALSE polynomial: 0x1021, init: 0xFFFF */
static const uint16_t crc_table[256] = {
    0x0000,0x1021,0x2042,0x3063,0x4084,0x50A5,0x60C6,0x70E7,
    0x8108,0x9129,0xA14A,0xB16B,0xC18C,0xD1AD,0xE1CE,0xF1EF,
    0x1231,0x0210,0x3273,0x2252,0x52B5,0x4294,0x72F7,0x62D6,
    0x9339,0x8318,0xB37B,0xA35A,0xD3BD,0xC39C,0xF3FF,0xE3DE,
    0x2462,0x3443,0x0420,0x1401,0x64E6,0x74C7,0x44A4,0x5485,
    0xA56A,0xB54B,0x8528,0x9509,0xE5EE,0xF5CF,0xC5AC,0xD58D,
    0x3653,0x2672,0x1641,0x0660,0x76D7,0x66F6,0x5695,0x46B4,
    0xB75B,0xA77A,0x9719,0x8738,0xF7DF,0xE7FE,0xD79D,0xC7BC,
    0x48C4,0x58E5,0x6886,0x78A7,0x0840,0x1861,0x2802,0x3823,
    0xC9CC,0xD9ED,0xE98E,0xF9AF,0x8948,0x9969,0xA90A,0xB92B,
    0x5AF5,0x4AD4,0x7AB7,0x6A96,0x1A71,0x0A50,0x3A33,0x2A12,
    0xDBFD,0xCBDC,0xFBBF,0xEB9E,0x9B79,0x8B58,0xBB3B,0xAB1A,
    0x6CA6,0x7C87,0x4CE4,0x5CC5,0x2C22,0x3C03,0x0C60,0x1C41,
    0xEDAE,0xFD8F,0xCDEC,0xDDCD,0xAD2A,0xBD0B,0x8D68,0x9D49,
    0x7E97,0x6EB6,0x5ED5,0x4EF4,0x3E13,0x2E32,0x1E51,0x0E70,
    0xFF9F,0xEFBE,0xDFDD,0xCFFC,0xBF1B,0xAF3A,0x9F59,0x8F78,
    0x9188,0x81A9,0xB1CA,0xA1EB,0xD10C,0xC12D,0xF14E,0xE16F,
    0x1080,0x00A1,0x30C2,0x20E3,0x5004,0x4025,0x7046,0x6067,
    0x83B9,0x9398,0xA3FB,0xB3DA,0xC33D,0xD31C,0xE37F,0xF35E,
    0x02B1,0x1290,0x22F3,0x32D2,0x4235,0x5214,0x6277,0x7256,
    0xB5EA,0xA5CB,0x95A8,0x8589,0xF56E,0xE54F,0xD52C,0xC50D,
    0x34E2,0x24C3,0x1490,0x04B1,0x7456,0x6477,0x5414,0x4435,
    0xA7C1,0xB7E0,0x8783,0x97A2,0xE745,0xF764,0xC727,0xD706,
    0x26E9,0x36C8,0x06AB,0x168A,0x666D,0x764C,0x462F,0x560E,
    0xED4C,0xFD6D,0xCDBE,0xDD9F,0xAD78,0xBD59,0x8D3A,0x9D1B,
    0x7EB7,0x6E96,0x5EF5,0x4ED4,0x3E33,0x2E12,0x1E71,0x0E50,
    0xFFCF,0xEFEE,0xDFCD,0xCFEC,0xBFAB,0xAF8A,0x9FE9,0x8FC8,
    0x9188,0x81A9,0xB1CA,0xA1EB,0xD10C,0xC12D,0xF14E,0xE16F,
    0x1080,0x00A1,0x30C2,0x20E3,0x5004,0x4025,0x7046,0x6067,
    0x83B9,0x9398,0xA3FB,0xB3DA,0xC33D,0xD31C,0xE37F,0xF35E,
    0x02B1,0x1290,0x22F3,0x32D2,0x4235,0x5214,0x6277,0x7256,
    0xB5EA,0xA5CB,0x95A8,0x8589,0xF56E,0xE54F,0xD52C,0xC50D,
};

uint16_t postsync_crc16(const uint8_t *data, uint16_t len)
{
    uint16_t crc = 0xFFFF;
    for (uint16_t i = 0; i < len; i++) {
        crc = (crc << 8) ^ crc_table[((crc >> 8) ^ data[i]) & 0xFF];
    }
    return crc;
}

void postsync_build_frame(postsync_frame_t *frame, uint16_t src, uint16_t dst,
                          uint8_t msg_type, uint16_t seq, const uint8_t *payload, uint8_t plen)
{
    if (plen > FRAME_PAYLOAD_MAX) plen = FRAME_PAYLOAD_MAX;

    frame->preamble[0] = 0xAA;
    frame->preamble[1] = 0xAA;
    frame->preamble[2] = 0xAA;
    frame->preamble[3] = 0xAA;
    frame->sync[0] = SYNC_WORD_0;
    frame->sync[1] = SYNC_WORD_1;
    frame->length = plen;
    frame->src_id = src;
    frame->dst_id = dst;
    frame->msg_type = msg_type;
    frame->seq_num = seq;
    if (plen > 0 && payload) {
        memcpy(frame->payload, payload, plen);
    }
    if (plen < FRAME_PAYLOAD_MAX) {
        memset(&frame->payload[plen], 0, FRAME_PAYLOAD_MAX - plen);
    }

    /* CRC covers header + payload (not preamble/sync/CRC field) */
    uint16_t crc_len = 1 + 2 + 2 + 1 + 2 + plen; /* length + src + dst + type + seq + payload */
    uint8_t crc_buf[FRAME_HEADER_LEN + FRAME_PAYLOAD_MAX];
    crc_buf[0] = frame->length;
    memcpy(&crc_buf[1], &frame->src_id, 2);
    memcpy(&crc_buf[3], &frame->dst_id, 2);
    crc_buf[5] = frame->msg_type;
    memcpy(&crc_buf[6], &frame->seq_num, 2);
    memcpy(&crc_buf[8], frame->payload, plen);
    frame->crc = postsync_crc16(crc_buf, crc_len);
}

bool postsync_parse_frame(const uint8_t *raw, uint16_t len, postsync_frame_t *out)
{
    if (len < FRAME_HEADER_LEN + FRAME_CRC_LEN) return false;
    if (len > sizeof(postsync_frame_t)) return false;

    memcpy(out, raw, len);

    /* Verify preamble */
    for (int i = 0; i < 4; i++) {
        if (out->preamble[i] != 0xAA) return false;
    }
    /* Verify sync word */
    if (out->sync[0] != SYNC_WORD_0 || out->sync[1] != SYNC_WORD_1) return false;

    return postsync_verify_crc(out);
}

bool postsync_verify_crc(const postsync_frame_t *frame)
{
    uint8_t plen = frame->length;
    if (plen > FRAME_PAYLOAD_MAX) return false;

    uint16_t crc_len = 1 + 2 + 2 + 1 + 2 + plen;
    uint8_t crc_buf[FRAME_HEADER_LEN + FRAME_PAYLOAD_MAX];
    crc_buf[0] = frame->length;
    memcpy(&crc_buf[1], &frame->src_id, 2);
    memcpy(&crc_buf[3], &frame->dst_id, 2);
    crc_buf[5] = frame->msg_type;
    memcpy(&crc_buf[6], &frame->seq_num, 2);
    memcpy(&crc_buf[8], frame->payload, plen);

    uint16_t computed = postsync_crc16(crc_buf, crc_len);
    return computed == frame->crc;
}