/*
 * CycleGuard shared protocol implementation
 * CRC-16/CCITT, frame build/parse, payload packing
 */

#include "protocol.h"
#include <string.h>

/* CRC-16/CCITT-FALSE polynomial 0x1021, init 0xFFFF */
static const uint16_t crc_table[256] = {
    0x0000,0x1021,0x2042,0x3063,0x4084,0x50A5,0x60C6,0x70E7,
    0x8108,0x9129,0xA14A,0xB16B,0xC18C,0xD1AD,0xE1CE,0xF1EF,
    0x1231,0x0210,0x3273,0x2252,0x52B5,0x4294,0x72F7,0x62D6,
    0x9339,0x8318,0xB37B,0xA35A,0xD3BD,0xC39C,0xF3FF,0xE3DE,
    0x2462,0x3443,0x0420,0x1401,0x64E6,0x74C7,0x44A4,0x5485,
    0xA56A,0xB54B,0x8528,0x9509,0xE5EE,0xF5CF,0xC5AC,0xD58D,
    0x3653,0x2672,0x1611,0x0630,0x76D7,0x66F6,0x5695,0x46B4,
    0xB75B,0xA77A,0x9719,0x8738,0xF7DF,0xE7FE,0xD79D,0xC7BC,
    0x48C4,0x58E5,0x6886,0x78A7,0x0840,0x1861,0x2802,0x3823,
    0xC9CC,0xD9ED,0xE98E,0xF9AF,0x8948,0x9969,0xA90A,0xB92B,
    0x5AF5,0x4AD4,0x7AB7,0x6A96,0x1A71,0x0A50,0x3A33,0x2A12,
    0xDBFD,0xCBDC,0xFBBF,0xEB9E,0x9B79,0x8B58,0xBB3B,0xAB1A,
    0x6CA6,0x7C87,0x4CE4,0x5CC5,0x2C22,0x3C03,0x0C60,0x1C41,
    0xEDAE,0xFD8F,0xCDEC,0xDDCD,0xAD2A,0xBD0B,0x8D68,0x9D49,
    0x7E97,0x6EB6,0x5ED5,0x4EF4,0x3E13,0x2E32,0x1E51,0x0E70,
    0xFF9F,0xEFBE,0xDFDD,0xCFFC,0xBF1B,0xAF3A,0x9F59,0x8F78,
    0x9188,0x81A9,0xB1CA,0xA1EB,0xD10C,0xC12D,0xF14E,0xE16F,
    0x1080,0x00A1,0x30C2,0x20E3,0x5004,0x4025,0x6046,0x7067,
    0x83B9,0x9398,0xA3FB,0xB3DA,0xC33D,0xD31C,0xE37F,0xF35E,
    0x02B1,0x1290,0x22F3,0x32D2,0x5235,0x4214,0x7277,0x6256,
    0x0B5A,0x1B7B,0x2B18,0x3B39,0x4B5E,0x5B7F,0x6B1C,0x7B3D,
    0x8BE2,0x9BC3,0xAB80,0xBBE1,0xCB06,0xDB27,0xEB44,0xFB65,
    0x4F8B,0x5FAA,0x6FC9,0x7FE8,0x0F0F,0x1F2E,0x2F4D,0x3F6C,
    0xDFA3,0xCF82,0xFFE1,0xEFC0,0xAF27,0xBF06,0x8F65,0x9F44,
    0x6E1E,0x7E3F,0x4E5C,0x5E7D,0x2E1A,0x3E3B,0x0E58,0x1E79,
    0xAE36,0xBE17,0x8E74,0x9E55,0x0EB2,0x1E93,0x2EF0,0x3ED1,
    0x4DAB,0x5D8A,0x6DE9,0x7DC8,0x0D2F,0x1D0E,0x2D6D,0x3D4C,
    0xBD23,0xAD02,0x9D61,0x8D40,0xFDA7,0xED86,0xDDE5,0xCDC4,
    0x7DA9,0x6D88,0x5DEB,0x4DCA,0x7D2D,0x6D0C,0x5D6F,0x4D4E,
    0xF6B1,0xE690,0xD6F3,0xC6D2,0xB635,0xA614,0x9677,0x8656,
    0x56B8,0x4699,0x76FA,0x66DB,0x163C,0x061D,0x367E,0x265F,
    0xD7B0,0xC791,0xB7F2,0xA7D3,0x7734,0x6715,0x5776,0x4757,
};

uint16_t protocol_crc16(const uint8_t *data, size_t len)
{
    uint16_t crc = 0xFFFF;
    for (size_t i = 0; i < len; i++) {
        crc = (crc << 8) ^ crc_table[((crc >> 8) ^ data[i]) & 0xFF];
    }
    return crc;
}

void protocol_build_frame(mesh_frame_t *frame, uint16_t src, uint16_t dst,
                           uint8_t msg_type, uint16_t seq,
                           const uint8_t *payload, uint8_t payload_len)
{
    if (payload_len > FRAME_PAYLOAD_MAX) payload_len = FRAME_PAYLOAD_MAX;

    frame->preamble[0] = 0x55;
    frame->preamble[1] = 0x55;
    frame->preamble[2] = 0x55;
    frame->preamble[3] = 0x55;
    frame->sync[0] = SYNC_WORD_0;
    frame->sync[1] = SYNC_WORD_1;
    frame->length   = payload_len;
    frame->src_id   = src;
    frame->dst_id   = dst;
    frame->msg_type = msg_type;
    frame->seq_num  = seq;
    memset(frame->payload, 0, FRAME_PAYLOAD_MAX);
    if (payload && payload_len > 0) {
        memcpy(frame->payload, payload, payload_len);
    }

    /* CRC covers header + payload (not preamble, sync, or CRC field) */
    uint8_t buf[FRAME_HEADER_LEN + FRAME_PAYLOAD_MAX];
    buf[0] = frame->length;
    buf[1] = (frame->src_id >> 8) & 0xFF;
    buf[2] = frame->src_id & 0xFF;
    buf[3] = (frame->dst_id >> 8) & 0xFF;
    buf[4] = frame->dst_id & 0xFF;
    buf[5] = frame->msg_type;
    buf[6] = (frame->seq_num >> 8) & 0xFF;
    buf[7] = frame->seq_num & 0xFF;
    memcpy(&buf[8], frame->payload, FRAME_PAYLOAD_MAX);
    frame->crc = protocol_crc16(buf, 8 + FRAME_PAYLOAD_MAX);
}

bool protocol_parse_frame(const uint8_t *raw, size_t len, mesh_frame_t *out)
{
    if (len < FRAME_MAX_LEN) return false;

    /* Check preamble */
    for (int i = 0; i < FRAME_PREAMBLE_LEN; i++) {
        if (raw[i] != 0x55) return false;
    }
    /* Check sync word */
    if (raw[4] != SYNC_WORD_0 || raw[5] != SYNC_WORD_1) return false;

    memcpy(out->preamble, raw, FRAME_PREAMBLE_LEN);
    memcpy(out->sync, raw + 4, FRAME_SYNC_LEN);
    out->length   = raw[6];
    out->src_id   = (raw[7] << 8) | raw[8];
    out->dst_id   = (raw[9] << 8) | raw[10];
    out->msg_type = raw[11];
    out->seq_num  = (raw[12] << 8) | raw[13];
    memcpy(out->payload, raw + 14, FRAME_PAYLOAD_MAX);
    out->crc = (raw[46] << 8) | raw[47];

    return protocol_validate_crc(out);
}

bool protocol_validate_crc(const mesh_frame_t *frame)
{
    uint8_t buf[8 + FRAME_PAYLOAD_MAX];
    buf[0] = frame->length;
    buf[1] = (frame->src_id >> 8) & 0xFF;
    buf[2] = frame->src_id & 0xFF;
    buf[3] = (frame->dst_id >> 8) & 0xFF;
    buf[4] = frame->dst_id & 0xFF;
    buf[5] = frame->msg_type;
    buf[6] = (frame->seq_num >> 8) & 0xFF;
    buf[7] = frame->seq_num & 0xFF;
    memcpy(&buf[8], frame->payload, FRAME_PAYLOAD_MAX);
    uint16_t calc = protocol_crc16(buf, 8 + FRAME_PAYLOAD_MAX);
    return calc == frame->crc;
}