/*
 * mesh_protocol.c — Shared Sub-GHz mesh protocol implementation
 *
 * CRC-16/CCITT, packet build/parse — used by all ThermoGrid nodes
 */

#include "mesh_protocol.h"
#include <string.h>

/* CRC-16/CCITT-FALSE: poly=0x1021, init=0xFFFF, no reflect */
static const uint16_t crc16_table[256] = {
    0x0000,0x1021,0x2042,0x3063,0x4084,0x50A5,0x60C6,0x70E7,
    0x8108,0x9129,0xA14A,0xB16B,0xC18C,0xD1AD,0xE1CE,0xF1EF,
    0x1231,0x0210,0x3273,0x2252,0x52B5,0x4294,0x72F7,0x62D6,
    0x9339,0x8318,0xB37B,0xA35A,0xD3BD,0xC39C,0xF3FF,0xE3DE,
    0x2462,0x3443,0x0420,0x1401,0x64E6,0x7487,0x4444,0x5475,
    0xA56A,0xB54B,0x8528,0x9509,0xE5EE,0xF5CF,0xC5AC,0xD58D,
    0x3653,0x2672,0x1611,0x0630,0x76D7,0x66F6,0x5695,0x4684,
    0xB97B,0xA95A,0x7969,0x6958,0x59C5,0x49FD,0x3F1C,0x2F3D,
    0x4A42,0x5A63,0x6A40,0x7A21,0x0A5C,0x1A7D,0x2A1E,0x3A3F,
    0xCB22,0xDB03,0xEB60,0xFB41,0x8B26,0x9B07,0xAB64,0xBB45,
    0x7ACA,0x6AEB,0x5A88,0x4AA9,0x3A4E,0x2A6F,0x1A0C,0x0A2D,
    0xFB52,0xEB73,0xDB10,0xCB31,0xBB56,0xAB77,0x9B14,0x8B35,
    0x6D8A,0x7DAB,0x4DC8,0x5DE9,0x2D0E,0x3D2F,0x0D4C,0x1D6D,
    0xFE32,0xEE13,0xDE70,0xCE51,0xBE36,0xAE17,0x9E74,0x8E55,
    0x7D7A,0x6D5B,0x5D38,0x4D19,0x3D7E,0x2D5F,0x1D3C,0x0D1D,
    0x0F2A,0x1F0B,0x2F68,0x3F49,0x4F2E,0x5F0F,0x6F6C,0x7F4D,
    0x8F42,0x9F63,0xAF00,0xBF21,0xCF46,0xDF67,0xEF04,0xFF25,
    0xBF4A,0xAF6B,0x9F08,0x8F29,0xFF4E,0xEF6F,0xDF0C,0xCF2D,
    0xEF92,0xFFB3,0x8FD0,0x9FF1,0x6F16,0x7F37,0x4F54,0x5F75,
    0x3F1A,0x2F3B,0x1F58,0x0F79,0xFF1E,0xEF3F,0xDF5C,0xCF7D,
    0xAF12,0xBF33,0x8F50,0x9F71,0x6F94,0x7FB5,0x4FD6,0x5FF7,
    0x2FC9,0x3FE8,0x0F8B,0x1FAA,0x4F4D,0x5F6C,0x6F0F,0x7F2E,
    0x1F41,0x0F60,0x3F03,0x2F22,0x5FC5,0x4FE4,0x7F87,0x6FA6,
    0xFF89,0xEFA8,0xDFCB,0xCFEA,0xBF0D,0xAF2C,0x9F4F,0x8F6E,
    0x0700,0x1721,0x2742,0x3763,0x4784,0x57A5,0x67C6,0x77E7,
    0x9708,0x8729,0xB74A,0xA76B,0xD78C,0xC7AD,0xE7CE,0xF7EF,
    0x1531,0x0510,0x3573,0x2252,0x52B5,0x4294,0x72F7,0x62D6,
    0x9339,0x8318,0xB37B,0xA35A,0xD3BD,0xC39C,0xF3FF,0xE3DE,
    0x2462,0x3443,0x0420,0x1401,0x64E6,0x7487,0x4444,0x5475,
    0xA56A,0xB54B,0x8528,0x9509,0xE5EE,0xF5CF,0xC5AC,0xD58D,
    0x3653,0x2672,0x1611,0x0630,0x76D7,0x66F6,0x5695,0x4684,
    0xB97B,0xA95A,0x7969,0x6958,0x59C5,0x49FD,0x3F1C,0x2F3D
};

uint16_t mesh_crc16(const uint8_t *data, uint16_t len)
{
    uint16_t crc = 0xFFFF;
    for (uint16_t i = 0; i < len; i++) {
        crc = (crc << 8) ^ crc16_table[((crc >> 8) ^ data[i]) & 0xFF];
    }
    return crc;
}

uint16_t mesh_build_packet(uint8_t src, uint8_t dst, uint8_t type,
                            const uint8_t *payload, uint8_t payload_len,
                            mesh_packet_t *out)
{
    if (payload_len > MESH_MAX_PAYLOAD)
        payload_len = MESH_MAX_PAYLOAD;

    memset(out, 0, sizeof(*out));
    out->preamble[0] = 0xAA;
    out->preamble[1] = 0xAA;
    out->preamble[2] = 0xAA;
    out->preamble[3] = 0xAA;
    out->sync      = MESH_SYNC_WORD;
    out->len       = payload_len;
    out->src_id    = src;
    out->dst_id    = dst;
    out->pkt_type  = type;
    if (payload && payload_len > 0)
        memcpy(out->payload, payload, payload_len);

    /* CRC over len + src + dst + type + payload */
    uint8_t crc_buf[4 + MESH_MAX_PAYLOAD];
    crc_buf[0] = out->len;
    crc_buf[1] = out->src_id;
    crc_buf[2] = out->dst_id;
    crc_buf[3] = out->pkt_type;
    if (payload_len > 0)
        memcpy(&crc_buf[4], out->payload, payload_len);
    out->crc16 = mesh_crc16(crc_buf, 4 + payload_len);

    /* Return total packet size */
    return (uint16_t)(4 + 2 + 1 + 1 + 1 + 1 + payload_len + 2);
}

int8_t mesh_parse_packet(const uint8_t *raw, uint16_t raw_len, mesh_packet_t *out)
{
    if (raw_len < 12)
        return -1;

    if (raw[0] != 0xAA || raw[1] != 0xAA || raw[2] != 0xAA || raw[3] != 0xAA)
        return -2;

    memcpy(out, raw, raw_len);
    if (out->sync != MESH_SYNC_WORD)
        return -3;

    uint8_t crc_buf[4 + MESH_MAX_PAYLOAD];
    crc_buf[0] = out->len;
    crc_buf[1] = out->src_id;
    crc_buf[2] = out->dst_id;
    crc_buf[3] = out->pkt_type;
    if (out->len > 0) {
        if (out->len > MESH_MAX_PAYLOAD)
            return -4;
        memcpy(&crc_buf[4], out->payload, out->len);
    }
    uint16_t calc_crc = mesh_crc16(crc_buf, 4 + out->len);
    if (calc_crc != out->crc16)
        return -5;

    return 0;
}